options:
  parameters:
    author: awb-devs
    description: This flow automatically records the preamble at Nyquist minimum sampling rate for incoming lora signals
    generate_options: qt_gui
    id: lora_preamble_collector
    output_language: python
    title: lora_preamble_collector
  states: {}

blocks:
- name: bandpass125k
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: lora_125bandwidth/2
    low_cutoff_freq: '-lora_125bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: lora_125bandwidth/10
    win: window.WIN_HAMMING
  states: {}
- name: bandpass250k
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: lora_250bandwidth/2
    low_cutoff_freq: '-lora_250bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: lora_250bandwidth/10
    win: window.WIN_HAMMING
  states: {}
- name: bandpass62k
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: lora_62bandwidth/2
    low_cutoff_freq: '-lora_62bandwidth/2'
    samp_rate: samp_rate
    type: complex_band_pass
    width: lora_62bandwidth/10
    win: window.WIN_HAMMING
  states: {}
- name: center_125KHz
  id: variable
  parameters:
    value: '904437500'
  states: {}
- name: center_250KHz
  id: variable
  parameters:
    value: '906875000'
  states: {}
- name: center_62KHz
  id: variable
  parameters:
    value: '916218750'
  states: {}
- name: cr_44
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cr_45
  id: variable
  parameters:
    value: '1'
  states: {}
- name: cr_46
  id: variable
  parameters:
    value: '2'
  states: {}
- name: cr_47
  id: variable
  parameters:
    value: '3'
  states: {}
- name: cr_48
  id: variable
  parameters:
    value: '8'
  states: {}
- name: has_crc
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: impl_head
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: lora_125bandwidth
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: lora_250bandwidth
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: lora_62bandwidth
  id: variable
  parameters:
    value: '62500'
  states: {}
- name: payload_length
  id: variable
  parameters:
    value: '237'
  states: {}
- name: preamble_length
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: soft_decoding
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: sync_word
  id: variable
  parameters:
    comment: |-
      Technically the sync-word here for meshtastic is 0x2b
      Trying this leads to no data gathered.
      Using the [0,0] works.
    value: '[0x12]'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: '''iq_samples/test/test'''
    SF: '7'
    _source_code: "import numpy as np\nimport pmt\nfrom gnuradio import gr\nfrom datetime import datetime\n\nclass blk(gr.sync_block):\n    \"\"\"Save iq samples on triggered output\"\"\"\n\n    def __init__(self, SF=7, N='None'):\n        \"\"\"arguments to this show up as params in grc\"\"\"\n        gr.sync_block.__init__(\n                self,\n                name = 'Triggered IQ Record',\n                in_sig = [np.complex64],\n                out_sig = None\n                )\n        self.sf = SF\n        self.device_note = N\n        self.preamble_frame_len = 8 * int(pow(2, SF))\n        # preallocated preamble array\n        self.preamble_buffer = np.zeros(self.preamble_frame_len, dtype=np.complex64)\n        self.collected_preamble_samples = 0\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n\n        # collect 'frame_info' from tags \n        info = None\n        tags = self.get_tags_in_window(0, 0, len(in0))\n        for tag in tags:\n            key = pmt.to_python(tag.key)\n            if key == 'frame_info':\n                info = {\n                        'offset': tag.offset,\n                        'key': key,\n                        'value': pmt.to_python(tag.value),\n                        }\n        \n        \n        if self.collected_preamble_samples == 0:\n            if info is None:\n                print(\"No Tag\")\n                return len(in0)\n            elif not info['value']['is_header']:\n                print(\"Not header\")\n                return len(in0)\n            print(\"HEADER FOUNDDDDDDD\")\n            print(f\"Tag at sample {info['offset']}: {info['key']} = {info['value']}\")\n            print(f\"Frame size: {self.preamble_frame_len}\")\n            print(f\"items read: {self.nitems_read(0)}\")\n            print(f\"buffer len: {len(in0)}\")\n            start = info['offset'] - self.nitems_read(0)\n            end = start + self.preamble_frame_len\n        else:\n            start = 0\n            end = start + (self.preamble_frame_len - self.collected_preamble_samples)\n\n        if len(in0) < end:\n            end = len(in0)\n            self.preamble_buffer[self.collected_preamble_samples:self.collected_preamble_samples + end - start] = in0[start:end]\n            self.collected_preamble_samples += end - start\n        else:\n            self.preamble_buffer[self.collected_preamble_samples:self.collected_preamble_samples + end - start] = in0[start:end]\n            timestamp = datetime.now().strftime(\"%Y-%m-%d_%H-%M-%S\")\n            file_name = f\"{self.device_note}_{timestamp}.cfile\"\n            self.preamble_buffer.tofile(file_name)\n            self.collected_preamble_samples = 0\n            print(\"SAVED\")\n\n        return len(in0)\n\n"
    comment: |-
      here SF is the most important factor to nail
      it's assumed that Samplerate = Bandwidth
      ( that should be true from the frame sync if setup correctly)
      Files are saved as N_timestamp.cfile
      N can include a path but make sure the folders exist already
      format is complex float 64
      length will be 8 * int(2^SF)
      ( 8 symbols * 2^SF samples per symbol )
      ( only true if SR/BW = 1 )
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    comment: |-
      Set Minoutbuf = 17000
      Frame Sync needs that
    decim: int(samp_rate/(lora_250bandwidth * 4))
    minoutbuf: '17000'
    samp_rate: samp_rate
    taps: bandpass250k
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: lora_sdr_crc_verif_0
  id: lora_sdr_crc_verif
  parameters:
    comment: Not strictly needed but usefull feedback
    output_crc_check: 'False'
    print_rx_msg: '2'
  states: {}
- name: lora_sdr_deinterleaver_0
  id: lora_sdr_deinterleaver
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_dewhitening_0
  id: lora_sdr_dewhitening
  parameters: {}
  states: {}
- name: lora_sdr_fft_demod_0
  id: lora_sdr_fft_demod
  parameters:
    max_log_approx: 'True'
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_frame_sync_0
  id: lora_sdr_frame_sync
  parameters:
    bandwidth: lora_250bandwidth
    center_freq: center_250KHz
    comment: |-
      ShortFast
      SF=7, CR=5, BW=250KHz
    impl_head: impl_head
    os_factor: '4'
    preamb_len: preamble_length
    sf: '7'
    show_log_port: 'True'
    sync_word: sync_word
  states: {}
- name: lora_sdr_gray_mapping_0
  id: lora_sdr_gray_mapping
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_hamming_dec_0
  id: lora_sdr_hamming_dec
  parameters:
    soft_decoding: soft_decoding
  states: {}
- name: lora_sdr_header_decoder_0
  id: lora_sdr_header_decoder
  parameters:
    cr: cr_45
    has_crc: has_crc
    impl_head: impl_head
    ldro: '2'
    pay_len: payload_length
    print_header: 'True'
  states: {}
- name: note_0_0
  id: note
  parameters:
    comment: |-
      This flow needs a dependency.
      https://github.com/tapparelj/gr-lora_sdr
    note: 'This flow needs a dependency: https://github.com/tapparelj/gr-lora_sdr'
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    comment: |-
      The radio_frequency_center is the center where the SDR tunes to.
      The 3 vars: center_250KHz, center_125KHz, and center_62KHz are absolute freqs
      The FIR filter extracts 4x the band size for LoRa processing.
      To get data programatically, connect to this machine's port TCP/20000-20007
    note: README
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '250000'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '250000'
    fc: center_250KHz
    fftsize: '8192'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: center_250KHz
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_sink_0_0_2_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://0.0.0.0:20000
    comment: Use for meshtastic decoding when applicable!
    timeout: '100'
    type: byte
  states: {state: disabled}

connections:
- [blocks_correctiq_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle2_0, '0', blocks_correctiq_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_sdr_frame_sync_0, '0']
- [lora_sdr_crc_verif_0, '0', zeromq_pub_sink_0_0_2_0, '0']
- [lora_sdr_deinterleaver_0, '0', lora_sdr_hamming_dec_0, '0']
- [lora_sdr_dewhitening_0, '0', lora_sdr_crc_verif_0, '0']
- [lora_sdr_fft_demod_0, '0', lora_sdr_gray_mapping_0, '0']
- [lora_sdr_frame_sync_0, '0', epy_block_0, '0']
- [lora_sdr_frame_sync_0, '0', lora_sdr_fft_demod_0, '0']
- [lora_sdr_frame_sync_0, '0', qtgui_time_sink_x_0, '0']
- [lora_sdr_gray_mapping_0, '0', lora_sdr_deinterleaver_0, '0']
- [lora_sdr_hamming_dec_0, '0', lora_sdr_header_decoder_0, '0']
- [lora_sdr_header_decoder_0, '0', lora_sdr_dewhitening_0, '0']
- [lora_sdr_header_decoder_0, frame_info, lora_sdr_frame_sync_0, frame_info]
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [soapy_hackrf_source_0, '0', blocks_throttle2_0, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
